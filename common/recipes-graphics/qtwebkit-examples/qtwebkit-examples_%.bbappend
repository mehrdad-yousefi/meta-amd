OE_QMAKE_PATH_EXAMPLES_amd = "/opt/qt5/examples"
