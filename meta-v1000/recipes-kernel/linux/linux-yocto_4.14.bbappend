require linux-yocto-v1000_4.14.inc

SRC_URI_append_v1000 += "file://v1000-standard-only.cfg"
