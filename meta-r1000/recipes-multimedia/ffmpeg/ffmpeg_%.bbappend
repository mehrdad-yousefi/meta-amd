PACKAGECONFIG_append_r1000 = " vaapi"
