RDEPENDS_${PN}_append_r1000 = " ffmpeg"
