SRCREV_amdgpu = "d5e17dc4c78aee5d37de399728066b9be881e044"
PV_amdgpu = "amdgpu-18.1.0"
