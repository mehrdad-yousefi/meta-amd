PACKAGECONFIG_append_r1000 = "dri3"
